# IAR project bitmarker_hw_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11C24FBD48_301 NXP LPC11C24FBD48_301
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: lpcopen\software\lpc_core\lpc_chip\chip_11xx\config_11cxx; lpcopen\software\lpc_core\lpc_chip\chip_common; lpcopen\software\lpc_core\lpc_chip\chip_11xx; lpcopen\software\CMSIS\CMSIS\Include; D:\20_Development\01_Embedded\LPC\lpc11C24_demo\logging; D:\20_Development\01_Embedded\LPC\lpc11C24_demo\general; D:\20_Development\01_Embedded\LPC\lpc11C24_demo\sensors
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: lpcopen\software\lpc_core\lpc_chip\chip_11xx\config_11cxx
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    general/: general.h
    lpcopen/applications/lpc11xx/startup_code/: iar_startup_lpc11xx.s sysinit.c
    ./: main.c
  group Modules
    logging/: logging.c logging.h uart.c uart.h
    sensors/: mcp9808.c mcp9808.h
  group Vendor
    lpcopen/software/lpc_core/lpc_chip/chip_11xx/iar_output/chip_11cxx_lib/Exe/: chip_11cxx_lib.a
